# Keil uVision project Robot_FreeRTOS.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Robot_FreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
STM32F10X_MD
  c include: ..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\SPL\inc;..\Config;..\App\Inc;..\BSP\Inc;..\Drivers\Inc;..\FreeRTOS\include;..\FreeRTOS\portable\GCC\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../App/Src/: main.c
  group CMSIS
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group SPL
    ../SPL/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group FreeRTOS
    ../FreeRTOS/Kernel/: list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/GCC/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group Config
    ../Config/: FreeRTOSConfig.h stm32f10x_conf.h
  group BSP
    ../BSP/Src/: bsp_encoder.c bsp_timer.c bsp_uart.c board.c
  group Drivers
    ../Drivers/Src/: encoder.c motor.c uart.c ultrasonic.c
